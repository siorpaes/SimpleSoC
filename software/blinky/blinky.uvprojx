# Keil uVision project blinky.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM1 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M1") CLOCK(12000000) ESEL ELITTLE
  output: blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x300
  memory RVCT9: RAM 0x300 size 0x100
  group Source Group 1
    ./: main.c startup.s
